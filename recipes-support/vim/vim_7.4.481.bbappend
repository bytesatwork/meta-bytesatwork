# Copyright (C) 2015 Daniel Ammann <daniel.ammann@bytesatwork.ch>
# Released under the MIT license (see COPYING.MIT for the terms)

# fix build error

SRC_URI[md5sum] = "17d5c30e1962db197804874a0e4e5e1e"
SRC_URI[sha256sum] = "f01b79b7b93946ea10ef319ee7b1d2f92e80cc6bf9290b310f038a08541396cc"
