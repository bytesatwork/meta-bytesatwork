# Copyright (C) 2014 Urs Fässler <urs.fassler@bytesatwork.ch>
# Released under the MIT license (see COPYING.MIT for the terms)

# remove dependency to X and multimedia codecs

PACKAGECONFIG_remove = "gtk libav"

