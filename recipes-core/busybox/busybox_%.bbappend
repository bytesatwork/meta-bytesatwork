FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
	file://gpt-label.cfg \
	file://udhcpc.cfg \
"
